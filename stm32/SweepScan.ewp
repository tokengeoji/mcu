# IAR project SweepScan.ewp, settings and files
configuration EMB_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ; config; board; Library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SweepScan.hex
  ILINK.IlinkOutputFile: SweepScan.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ALIGN_CENTER (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CENTER_ONLY=1
configuration BENCH_CHECK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BENCH_CHECK=1
  group (top)
    ./: main.c
  group config
    ./: stm32f10x_conf.h scan_config.h System_func.c
    config/: STM32F10x_FLASH.icf
  group cortex-m3
    board/: cortexm3_macro.s
  group Library
    Library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim1.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c
  group Vector
    ./: stm32f10x_it.c stm32f10x_vector.c
